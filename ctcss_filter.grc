options:
  parameters:
    generate_options: no_gui
    id: top_block
    output_language: python
    run_options: run
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: short
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: short
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '7356'
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: blocks_udp_sink_1
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '7355'
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '7354'
    psize: '9600'
    type: short
    vlen: '1'
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '300'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '40'
    win: firdes.WIN_HAMMING
  states: {}

connections:
- [blocks_deinterleave_0, '0', blocks_short_to_float_0, '0']
- [blocks_deinterleave_0, '1', blocks_null_sink_0, '0']
- [blocks_float_to_short_0, '0', blocks_interleave_0, '0']
- [blocks_float_to_short_0, '0', blocks_interleave_0, '1']
- [blocks_interleave_0, '0', blocks_udp_sink_0, '0']
- [blocks_short_to_float_0, '0', high_pass_filter_0, '0']
- [blocks_udp_source_0, '0', blocks_deinterleave_0, '0']
- [blocks_udp_source_0, '0', blocks_udp_sink_1, '0']
- [high_pass_filter_0, '0', blocks_float_to_short_0, '0']

metadata:
  file_format: 1
